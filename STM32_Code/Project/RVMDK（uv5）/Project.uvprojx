# Keil uVision project Project.uvprojx, settings and files
target BH_F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\User;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Bsp\bsp_systick;..\..\Bsp\bsp_uart;..\..\Bsp\bsp_gpio;..\..\Bsp\bsp_timer;..\..\Bsp\bsp_pwm;..\..\Bsp\bsp_usart_dma;..\..\User\key;..\..\User\led;..\..\Bsp\bsp_can;..\..\Bsp\bsp_eth;..\..\User\App;..\..\User\lwip-1.4.1\port;..\..\User\lwip-1.4.1\port\arch;..\..\User\lwip-1.4.1\port\Standalone;..\..\User\lwip-1.4.1\src\include;..\..\User\lwip-1.4.1\src\include\ipv4;..\..\User\lwip-1.4.1\src\include\lwip;..\..\User\lwip-1.4.1\src\include\netif;..\..\User\IO_IIC;..\..\User\MPU6050;..\..\User\DMP;..\..\Bsp\bsp_spi;..\..\User\FLASH;..\..\User\IMU;..\..\User\MOTOR_EULER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/key/: key.c
    ../../User/led/: led.c
    ../../User/Mick_IO/: Mick_IO.c
    ../../User/App/: netconf.c tcp_echoclient.c
    ../../User/DBUS/: DBUS.c
    ../../User/Battery/: Battery.c
    ../../User/MOTOR_Control/: MOTOR_Control.c
    ../../User/MOTOR_APSL2DB/: MOTOR_APSL2DB.c
    ../../User/MOTOR_RMD/: MOTOR_RMD.c
    ../../User/MOTOR_EULER/: MOTOR_EULER.c
    ../../User/IO_IIC/: IO_IIC.c
    ../../User/MPU6050/: MPU6050.c
    ../../User/IMU/: IMU.c
    ../../User/FLASH/: w25q128.c
    ../../User/Scope_API/: Scope_API.c
  group BSP
    ../../Bsp/bsp_systick/: bsp_systick.c
    ../../Bsp/bsp_spi/: bsp_spi.c
    ../../Bsp/bsp_gpio/: bsp_gpio.c
    ../../Bsp/bsp_timer/: bsp_timer.c
    ../../Bsp/bsp_uart/: bsp_uart.c
    ../../Bsp/bsp_usart_dma/: bsp_usart_dma.c
    ../../Bsp/bsp_pwm/: bsp_pwm.c
    ../../Bsp/bsp_can/: bsp_can.c
    ../../Bsp/bsp_eth/: stm32f4x7_eth.c stm32f4x7_phy.c
  group MPU6050DMP
    ../../User/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group LwIP_src_api
    ../../User/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_src_core_ipv4
    ../../User/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_src_core
    ../../User/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP_src_netif
    ../../User/lwip-1.4.1/src/netif/: etharp.c
  group LwIP_port
    ../../User/lwip-1.4.1/port/Standalone/: ethernetif.c
  group DOC
    ../../: ReadMe.txt
