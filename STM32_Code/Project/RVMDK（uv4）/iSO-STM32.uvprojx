# Keil uVision project iSO-STM32.uvprojx, settings and files
target Led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mickrobot +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\cpu;..\..\User\PID;..\..\User\MPU6050;..\..\User\LCD240x320_ILI9341;..\..\User\W25Q16;..\..\User\stm32f10x_pwm;..\..\User\SDIO_SD;..\..\User\LCD240x320_Touch;..\..\ff9\src;..\..\ff9\src\option;..\..\User\BMP180;..\..\User\HMC5883;..\..\User\IMU;..\..\User\IO_IIC;..\..\User\Kalman_Filter;..\..\User\NRF_24L01;..\..\User\Scope_API;..\..\User\Seven_Lab_MiniIMU;..\..\User\WS2812;..\..\User\Mick_IO;..\..\User\speed_control;..\..\User\bsp_can;..\..\User\bsp_uart;..\..\User\DBUS;..\..\User\DJI_Motor;..\..\User\MPU9250;..\..\User\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/cpu/: stm32f10x_Delay.c
    ../../User/stm32f10x_pwm/: stm32f10x_pwm.c
    ../../User/speed_control/: speed_control.c
    ../../User/bsp_uart/: bsp_uart.c
    ../../User/bsp_can/: bsp_can.c
    ../../User/DBUS/: DBUS.c
    ../../User/DJI_Motor/: DJI_Motor.c
    ../../User/PID/: PID.c
    ../../User/IO_IIC/: IO_IIC.c
    ../../User/MPU9250/: MPU9250.c
    ../../User/HMC5883/: HMC5883.c
    ../../User/MPU6050/: MPU6050.c
    ../../User/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/IMU/: IMU.c
    ../../User/Seven_Lab_MiniIMU/: Seven_Lab_MiniIMU.c
    ../../User/Mick_IO/: Mick_IO.c
  group DOC
    ../../Doc/: readme.txt
